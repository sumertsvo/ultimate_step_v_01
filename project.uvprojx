# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: -AT32F421F8P7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: at32f421_wk_config.h at32f421_int.h at32f421_wk_config.c at32f421_int.c main.c at32f421_conf.h
software components: CMSIS:CORE 5.0.1, Device:at32f421_conf 2.0.0, Device:at32f421_firmware_library:adc 2.0.0, Device:at32f421_firmware_library:crm 2.0.0, Device:at32f421_firmware_library:gpio 2.0.0, Device:at32f421_firmware_library:misc 2.0.0, Device:at32f421_firmware_library:tmr 2.0.0, Device:at32f421_firmware_library:wdt 2.0.0, Device:startup 2.0.0
